## boards/shields/corne/Kconfig.shield
```kconfig
if SHIELD_CORNE_LEFT || SHIELD_CORNE_RIGHT
config ZMK_DISPLAY
    def_bool y
endif
```
